# Keil uVision project LWIP.uvprojx, settings and files
target LWIP (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LWIP +hex
  c flags: Optim=3 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,STM32F40XX,USE_USB_OTG_FS,USE_EMBEDDED_PHY,USE_USB_OTG_HS
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\FWLIB\STM32F4xx_StdPeriph_Driver\inc;..\USER;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\ETHERNET;..\HARDWARE\TIMER;..\HARDWARE\LED;..\HARDWARE\BEEP;..\HARDWARE\RTC;..\HARDWARE\ADC;..\HARDWARE\SRAM;..\HARDWARE\InterTemperate;..\FWLIB\STM32F4x7_ETH_Driver\inc;..\MALLOC;..\USMART;..\HARDWARE;..\ETHERCAT
  asm misc: --diag_suppress=Pe000
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/ETHERNET/: DM9162.c DM9000.c
    ../HARDWARE/SRAM/: sram.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/: bsp_timer.c bsp.c
  group ETHERCAT
    ../ETHERCAT/: Ethercat_Master.c ethercatbase.c ethercatcoe.c ethercatconfig.c ethercatmain.c ethercatdc.c ethercatprint.c nicdrv.c
  group CORE
    ../CORE/: core_cm4.h core_cm4_simd.h startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_adc.c stm32f4xx_fsmc.c stm32f4xx_rtc.c stm32f4xx_exti.c stm32f4xx_pwr.c
    ../FWLIB/STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group README
    ../: readme.txt
